# Keil uVision project faceplate_CT.uvproj, settings and files
target faceplate_CT (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: faceplate_CT +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: .\CMSIS;.\Headers;.\Libraries\inc;.\Startup;.\User;.\Libraries\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/: stm32f0xx_it.c main.c key_logic.c
  group Headers
    ./Headers/: stm32f0xx_conf.h stm32f0xx_it.h main.h gpio_driver.h gpio_app.h key_logic.h uart_driver.h uart_app.h
  group Libraries
    ./Libraries/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMSIS
    ./CMSIS/: system_stm32f0xx.c
  group Startup
    ./Startup/: startup_stm32f0xx.s
  group Drivers
    ./User/Drivers/: gpio_driver.c uart_driver.c
  group DriverApp
    ./User/DriverApp/: gpio_app.c uart_app.c
